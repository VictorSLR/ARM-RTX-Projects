# IAR project Elevador.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.PreInclude: ..\..\Projects\Elevador\src\UART_Config.h
  ICCARM.CCIncludePath2: ..\drivers; ..\..\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Elevador.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../drivers/: driverleds.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    src/: elevador.c RTX_Config.c startup_TM4C1294.s system_TM4C1294_TW.c
    ../../CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/IDE/CM4F/Exe/: RTX_CM.a
    src/RTX/: rtx_lib.c
    ../../TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
